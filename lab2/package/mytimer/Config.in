## lab2/package/mytimer/Config.in
```kconfig
config BR2_PACKAGE_MYTIMER
    bool "mytimer"
    help
      Lab 2 task with
      switches and diodes
```
